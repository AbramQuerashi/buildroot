## hello/package/hello/Config.in
```kconfig
config BR2_PACKAGE_HELLO
	bool "hello"
	help
	  Minimal hello world package.

	  http://example.com/
```
